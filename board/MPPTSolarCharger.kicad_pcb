# Repository SaintGimp/MPPTSolarCharger

## KiCad design board/MPPTSolarCharger.kicad_pcb

Parts:
C1, C7, C12, C13: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C6, C9: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3: 1000uF; CP_16x25mm_horiz-R
C4, C10: 4.7uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C5: 100uF; CP_Radial_D6.3mm_P2.50mm
C8: 1nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C11: 1000uF; CP_16x25mm_horiz-L
D1, D2: 1N4148; D_SOD-323_HandSoldering
F1: Fuse; Fuseholder_Blade_ATO_Littelfuse_Pudenz_2_Pin
J1, J2: Screw_Terminal_01x02; Phoenix_Contact_MKDS_5-2-952
JP1: Jumper_NC_Dual; PinHeader_1x03_P2.54mm_Vertical
L1: 22uH; Coilcraft_SER2900
Q1, Q2, Q3: PSMN5R5-60YS; LFPAK56
R1: 1M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 150; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 1000; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R6: 3.3; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5: 2.2; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
TP1, TP2, TP4, TP5, TP6: TestPoint_Probe; TestPoint_Loop_D2.50mm_Drill1.0mm
U1: LM350_TO220; TO-220-3_Vertical
U2: MIC4605-1YM; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+10V: C5.1, C7.1, R2.1, U1.2 (VO), U2.1 (VDD)
/MCU/HIGH_PWM: U2.5 (HI); also elsewhere on the board
/MCU/LOW_PWM: U2.6 (LI); also elsewhere on the board
/PowerStage/BATTERY+: C13.1, F1.1, J2.1
/PowerStage/BUCK_IN: C3.1, C4.1, C6.1, Q2.5 (D), TP1.1; also elsewhere on the board
/PowerStage/BUCK_OUT: C9.1, C10.1, C11.1, JP1.3 (B), L1.2, TP5.1; also elsewhere on the board
/PowerStage/BatteryCurrentMonitor/IN-: F1.2; also elsewhere on the board
/PowerStage/HB: C12.1, U2.2 (HB)
/PowerStage/HIGH_DRIVER: R4.1, U2.3 (HO)
/PowerStage/HS: D2.1 (K), R6.1, TP6.1, U2.4 (HS)
/PowerStage/LOW_DRIVER: D1.2 (A), Q3.4 (G), TP2.1, U2.8 (LO)
/PowerStage/SOLAR+: C1.1, J1.1, JP1.1 (A); also elsewhere on the board
/PowerStage/SOLAR-: C1.2, J1.2, Q1.5 (D)
/PowerStage/SWITCH_NODE: C12.2, L1.1, Q2.1 (S), Q2.2 (S), Q2.3 (S), Q3.5 (D), R5.1, R6.2, TP4.1
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C13.2, D2.2 (A), J2.2, Q1.1 (S), Q1.2 (S), Q1.3 (S), Q3.1 (S), Q3.2 (S), Q3.3 (S), R1.1, R3.2, U2.7 (VSS); also elsewhere on the board
unnamed: C2.1, U1.3 (VI)
unnamed: C8.1, R5.2
unnamed: D1.1 (K), Q1.4 (G), R1.2
unnamed: Q2.4 (G), R4.2
unnamed: R2.2, R3.1, U1.1 (ADJ)

Notes on the sheet:
An external resistor between the LO output and the MOSFET may affect the performance of the LO pin monitoring circuit and is not recommended.
Adding a series resistor in the switch node limits the peak high-side driver current during turn-off, which affects the switching speed of the high-side driver. The resistor in series with the HO pin may be reduced to help compensate for the extra HS pin resistance.

Parts:
J3: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
R7, R8: 4.3K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder

Connections:
+3.3V: J3.1, R7.1, R8.1; also elsewhere on the board
/MCU/HIGH_PWM: J3.3; also elsewhere on the board
/MCU/LOW_PWM: J3.4; also elsewhere on the board
/MCU/SCL: J3.5, R8.2; also elsewhere on the board
/MCU/SDA: J3.6, R7.2; also elsewhere on the board
GND: J3.2; also elsewhere on the board

Parts:
C14, C15: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
U3: INA260; TSSOP-16_4.4x5mm_P0.65mm

Connections:
+3.3V: C15.1, U3.10 (Vs); also elsewhere on the board
/MCU/SCL: U3.9 (SCL); also elsewhere on the board
/MCU/SDA: U3.8 (SDA); also elsewhere on the board
/PowerStage/BUCK_IN: U3.14 (In-), U3.15 (In-), U3.16 (In-); also elsewhere on the board
/PowerStage/SOLAR+: C14.1, U3.1 (In+), U3.2 (In+), U3.3 (In+), U3.12 (Vbus); also elsewhere on the board
GND: C14.2, C15.2, U3.4 (A1), U3.5 (A0), U3.6 (GND), U3.11 (GND); also elsewhere on the board

Notes on the sheet:
I2C address 0x40

Parts:
C16, C17: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
U4: INA260; TSSOP-16_4.4x5mm_P0.65mm

Connections:
+3.3V: C17.1, U4.5 (A0), U4.10 (Vs); also elsewhere on the board
/MCU/SCL: U4.9 (SCL); also elsewhere on the board
/MCU/SDA: U4.8 (SDA); also elsewhere on the board
/PowerStage/BUCK_OUT: U4.1 (In+), U4.2 (In+), U4.3 (In+); also elsewhere on the board
/PowerStage/BatteryCurrentMonitor/IN-: C16.1, U4.12 (Vbus), U4.14 (In-), U4.15 (In-), U4.16 (In-); also elsewhere on the board
GND: C16.2, C17.2, U4.4 (A1), U4.6 (GND), U4.11 (GND); also elsewhere on the board

Notes on the sheet:
I2C address 0x41

Board: 4 copper layers, 45 parts (0 on the bottom side), 23 nets.

## KiCad design MPPTSolarCharger.kicad_pcb

Parts:
C16, C17: 100nF; C_0805_2012Metric
U4: INA260; TSSOP-16_4.4x5mm_P0.65mm

Connections:
+3V3: C17.1, U4.5 (A0), U4.10 (Vs); also elsewhere on the board
/MCU/SCL: U4.9 (SCL); also elsewhere on the board
/MCU/SDA: U4.8 (SDA); also elsewhere on the board
/PowerStage/BUCK_OUT: U4.1 (In+), U4.2 (In+), U4.3 (In+); also elsewhere on the board
/PowerStage/BatteryCurrentMonitor/IN-: C16.1, U4.12 (Vbus), U4.14 (In-), U4.15 (In-), U4.16 (In-); also elsewhere on the board
GND: C16.2, C17.2, U4.4 (A1), U4.6 (GND), U4.11 (GND); also elsewhere on the board

Notes on the sheet:
I2C address 0x41

Parts:
C1, C9, C12, C13: 1uF; C_0805_2012Metric
C2: 100nF; C_0805_2012Metric
C3, C4, C10, C11: 1000uF; CP_Radial_D16.0mm_P7.50mm
C5, C7: 4.7uF; C_0805_2012Metric
C6: 100uF; CP_Radial_D6.3mm_P2.50mm
C8: 1nF; C_0805_2012Metric
D1, D2: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
F1: Fuse; Fuseholder_Blade_ATO_Littelfuse_Pudenz_2_Pin
J1, J2: Screw_Terminal_01x02; TerminalBlock_Phoenix_MKDS-3-2-5.08_1x02_P5.08mm_Horizontal
JP1: Jumper_NC_Dual; PinHeader_1x03_P2.54mm_Vertical
JP2, JP4: Jumper_NC_Small; PinHeader_1x02_P2.54mm_Vertical
L1: 22uH; Coilcraft_SER2900
Q1, Q2, Q3: PSMN5R5-60YS; LFPAK56
R1: 1M; R_0805_2012Metric
R2: 150; R_0805_2012Metric
R3: 1000; R_0805_2012Metric
R4, R5: 3.3; R_0805_2012Metric
R6: 2.2; R_0805_2012Metric
R7: 3; R_0805_2012Metric
TP1, TP2, TP3, TP4, TP5, TP6: TestPoint_Probe; TestPoint_Loop_D2.50mm_Drill1.0mm
U1: LM350_TO220; TO-220-3_Vertical
U2: MIC4605-1YM; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+10V: C6.1, C12.1, R2.1, U1.2 (VO), U2.1 (VDD)
/MCU/HIGH_PWM: U2.5 (HI); also elsewhere on the board
/MCU/LOW_PWM: U2.6 (LI); also elsewhere on the board
/PowerStage/BATTERY+: C13.1, F1.1, J2.1
/PowerStage/BUCK_OUT: C10.1, JP1.3, JP4.1, L1.2, TP6.1; also elsewhere on the board
/PowerStage/BatteryCurrentMonitor/IN-: F1.2; also elsewhere on the board
/PowerStage/HS: D2.1 (K), R7.1, TP5.1, U2.4 (HS)
/PowerStage/LOW_DRIVER: R5.2, U2.8 (LO)
/PowerStage/SOLAR+: C1.1, C3.1, J1.1, JP1.1, JP2.1; also elsewhere on the board
/PowerStage/SOLAR-: C1.2, J1.2, Q1.5 (D)
/PowerStage/SWITCH_NODE: C9.1, L1.1, Q2.1 (S), Q2.2 (S), Q2.3 (S), Q3.5 (D), R6.1, R7.2, TP4.1
/PowerStage/SolarCurrentMonitor/IN-: C5.1, C7.1, Q2.5 (D), TP1.1; also elsewhere on the board
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C10.2, C11.2, C12.2, C13.2, D2.2 (A), J2.2, Q1.1 (S), Q1.2 (S), Q1.3 (S), Q3.1 (S), Q3.2 (S), Q3.3 (S), R1.1, R3.2, U2.7 (VSS); also elsewhere on the board
unnamed: C2.1, JP1.2, U1.3 (VI)
unnamed: C4.1, JP2.2
unnamed: C8.1, R6.2
unnamed: C11.1, JP4.2
unnamed: D1.1 (K), Q1.4 (G), R1.2
unnamed: D1.2 (A), Q3.4 (G), R5.1, TP2.1
unnamed: Q2.4 (G), R4.2, TP3.1
unnamed: R2.2, R3.1, U1.1 (ADJ)

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
Board: 2 copper layers, 150.5 x 49.5 mm, 49 parts (0 on the bottom side), 26 nets.

Other parts of the board:
C14, C15: 100nF; C_0805_2012Metric
J3: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
R8, R9: 4.3K; R_0805_2012Metric
U3: INA260; TSSOP-16_4.4x5mm_P0.65mm

Their connections:
+3V3: C15.1, J3.1, R8.1, R9.1, U3.10; also elsewhere on the board
/MCU/HIGH_PWM: J3.3; also elsewhere on the board
/MCU/LOW_PWM: J3.4; also elsewhere on the board
/MCU/SCL: J3.5, R9.2, U3.9; also elsewhere on the board
/MCU/SDA: J3.6, R8.2, U3.8; also elsewhere on the board
/PowerStage/SOLAR+: C14.1, U3.1, U3.2, U3.3, U3.12; also elsewhere on the board
/PowerStage/SolarCurrentMonitor/IN-: U3.14, U3.15, U3.16; also elsewhere on the board
GND: C14.2, C15.2, J3.2, U3.4, U3.5, U3.6, U3.11; also elsewhere on the board

## Commit log

2018-10-30 Initial commit of prototype board
2018-10-30 Move board to subfolder
2018-10-30 Experimental SAMD code
2020-01-09 Rev 2 of board layout, WIP
2022-08-06 Upgrade to KiCad 6
2022-08-26 Different board layout, WIP
